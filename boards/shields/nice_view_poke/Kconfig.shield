## boards/shields/nice_view_poke/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_POKE
    def_bool $(shields_list_contains,nice_view_poke)
```
